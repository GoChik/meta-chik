PACKAGECONFIG_rpi-0w_music = " \
    systemd \
"