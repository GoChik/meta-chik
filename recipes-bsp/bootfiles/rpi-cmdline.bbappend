CMDLINE_ROOT_FSTYPE = "rootfstype=btrfs"
CMDLINE_ROOT_PARTITION ?= "/dev/mmcblk0p2"