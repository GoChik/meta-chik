FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

COMPATIBLE = "(rpi-0w|rpi-0w_music|unipi-neuron)"
